# IAR project Bootloader.ewp, settings and files
configuration FVP (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Bootloader.out
  ILINK.IlinkIcfFile: ..\v2m-mps2_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main_s.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.2-dev2}$/CMSIS/Documentation/Core/html/: index.html
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.2-dev2}$/CMSIS/Include/: tz_context.h
  group CMSIS-Pack/Device Startup
    RTE/CMSIS/ARM/: partition_ARMCM23.h startup_ARMCM23.s system_ARMCM23.c
