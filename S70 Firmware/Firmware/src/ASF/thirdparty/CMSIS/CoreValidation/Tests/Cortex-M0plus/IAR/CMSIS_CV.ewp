# IAR project CMSIS_CV.ewp, settings and files
configuration FVP (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; $PROJ_DIR$; ..\..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CMSIS_CV.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt
    ../../../Source/: cmsis_cv.c CV_CoreFunc.c CV_CoreInstr.c CV_Framework.c CV_GenTimer.c CV_MPU_ARMv7.c CV_Report.c
    ../../: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1-dev1}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Startup
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1-dev1}$/Device/ARM/ARMCM0plus/Include/: ARMCM0plus.h
    RTE/CMSIS/ARM/: startup_ARMCM0plus.s system_ARMCM0plus.c
